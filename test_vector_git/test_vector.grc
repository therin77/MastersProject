options:
  parameters:
    comment: |-
      toDO
      -add autocorr function
    generate_options: qt_gui
    id: testautocorrelationfunction
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '3.14'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Kate\OSUProject\MastersProject\test_file
    type: complex
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, additionFlag=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Add or Multiply Block',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.additionFlag = additionFlag

          def work(self, input_items, output_items):
              """example: multiply with constant"""

              if self.additionFlag:
                  output_items[0][:] = input_items[0][:] + input_items[1][:]
              else:
                  output_items[0][:] = input_items[0][:] * input_items[1][:]

              return len(output_items[0])
    additionFlag: 'True'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\n\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, window=1.0, length=1024):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Correlation/Synch Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.window = window\n        self.length = length\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n\n        in_data = np.array(input_items[0])\n\n        if len(in_data) < self.length:\n            return 0\n\n        in_data = np.concatenate([np.zeros(self.length, dtype=np.complex64)])\n\n        corr_data = np.correlate(in_data, in_data)\n\n        #output_items[0][:] = input_items[0][:]*len(corr_data)\n        print(self.length)\n        print(len(in_data)-1)\n        \n        #Problem is here         \n        output_items[0][:self.length] = corr_data[len(in_data):]\n        \n        return len(output_items[0])\n"
    length: '1024'
    window: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_1, '0']
- [analog_sig_source_x_1, '0', epy_block_1, '1']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_2, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
